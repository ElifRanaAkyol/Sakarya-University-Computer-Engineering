	ORG 00H
	SJMP BASLA
	ORG 0023H
	SJMP SERI
	ORG 30H
BASLA:
	SETB IT1
	MOV TMOD, #20H
	MOV TL1, #-13
	MOV TH1, #-13
	MOV TCON, #50H
	MOV IE, #90H
	SETB TR1
	SJMP $
SERI:;JNB RI, SERI;RI 1 MI KONTROL EDER. 0 SA SERIYE GIDER
	CLR RI ;jnb RI y gerek yokru çünkü zaten 23H a RI 1 oldugunda gidilir
	MOV A, SBUF
	MOV R1, A
	SUBB A, #65H
	JNC, ZKONTROL
	SJMP FFYUKLE
ZKONTROL:
	MOV A, R1
	SUBB A, #90H
	JNC ,FFYUKLE
	SJMP KUCUK
FFYUKLE:
	MOV A, #0FFH
	SJMP GONDER
KUCUK:
	MOV A, R1
	ADD A, #32
GONDER:JNB TI
	CLR TI
	MOV SBUF,A
	RETI
	END
