ORG 0H
SJMP BASLA
ORG 3H
CLR TR1
SETB TR0
RETI
ORG 0BH
CPL P1.0
RETI
ORG 13H
CLR TR0
SETB TR1
RETI
ORG 1BH
CPL P1.0
RETI
ORG 30H
BASLA: MOV IE,#8FH
SETB IT0 ;düsen kenar
SETB IT1
SETB PX1
MOV TMOD,#22H
MOV TH0,#-10 ;50KHz için
MOV TL0,#-10
MOV TH1,#-25 ;20 KHz için
MOV TL1,#-25
SJMP $
END