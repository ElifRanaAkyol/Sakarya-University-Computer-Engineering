		ORG 00H
		SJMP BASLA
		
		ORG #0003H
		SJMP INT0KESME
		ORG #000BH
		SJMP T0KESME
		ORG #0013H
		SJMP INT1KESME
		ORG #001BH
		SJMP T1KESME
		
BASLA:	CLR P1.0
		CLR TF0
		CLR TR0
		CLR TF1
		CLR TR1
		MOV TMOD, #12H
		MOV TL0,#16
		MOV TH0, #16
		MOV TL1, #-50000
		MOV TH1, #-50000
		SETB IT0
		SETB IT1
		MOV IE #8F
		
		SJMP $
		
INT0KESME:
		CLR P3.2 ;?
		CLR P1.1
		MOV TL1, #-25000
		MOV TH1, #-25000
		SETB TR1
		RETI
T0KESME:
		CLR TF0 ;OTOMATIK OLDUGU ICIN TEKRAR KURMAYA GEREK YOK
		CPL P1.3
		RETI		
INT1KESME:
		SETB P1.1
		MOV TL1, #-50000
		MOV TH1, #-50000
		SETB TR1
		RETI
T1KESME:
		JB P1.0, CALISIYOR
		SETB P1.0
		SETB TR0
		SETB P1.2
		SJMP CALISMIYOR
		
CALISIYOR:
		CLR TR1
		CLR TF1 
		CPL P1.0
		CPL P1.2
		CLR TF0
		CLR TR0 
CALISMIYOR:
		RETI
		END
		